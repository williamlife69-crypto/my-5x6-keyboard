## config/boards/shields/my5x6/Kconfig.defconfig
```kconfig
# config/boards/shields/wf_key/Kconfig.defconfig

if SHIELD_WF_KEY

config ZMK_KEYBOARD_NAME
    default "WF Key"

endif
```
